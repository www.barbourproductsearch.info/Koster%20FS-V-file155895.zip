Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-15T11:50:00
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Wall:NBS_DeltaMembraneSystemsLtd_PolysulfideConstructionJointSealants_KosterJointSealantFS-V, Basic Wall:NBS_DeltaMembraneSystemsLtd_PolysulfideConstructionJointSealants_KosterJointSealantFS-V:222302
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_PolysulfideConstructionJointSealants_KosterJointSealantFS-V 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_31_76_62: Polysulfide construction joint sealants; Color: n/a; Finish: n/a; Material: Polysulphide; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Stiff/ creamy, two-component polysulphide joint sealant.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster Joint Sealant FS-V; Name: PolysulfideConstructionJointSealants_KosterJointSealantFS-V_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_PolysulfideConstructionJointSealants_KosterJointSealantFS-V; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/6123d9c0-ef7b-53b3-8abd-e73e43cc540b/0d015ec1-9021-4eb6-833d-ecf281dbe336; Uniclass2015Code: Pr_30_31_76_62; Uniclass2015Title: Polysulfide construction joint sealants; Uniclass2015Version: Products v1.35; Version: 6
Type - NBS_Data - SealantType: Two part polysulfide; Colour: Black,Grey; ContainsRedListMaterials: No; Recyclability: No; RecycledContent: 0; ApplicationTemperature: 5–40°C; Capacity: ≥80%; ConsumptionPerLayerApplied: 1.6 kg/L; CureTime: 24 H; DeformationCapability: 15%; JointWidthRange: 10–35 mm; MixingTime: 100:13 (A:B); PotLife: 2 H; ShoreAHardness: 35; SpecificGravity: 1.6 kg/L
Classification: Pr_30_31_76_62 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_DeltaMembraneSystemsLtd_PolysulfideConstructionJointSealants_KosterJointSealantFS-V, Floor:NBS_DeltaMembraneSystemsLtd_PolysulfideConstructionJointSealants_KosterJointSealantFS-V:222142
In: Level 0
Type - Material: NBS_DeltaMembraneSystemsLtd_PolysulfideConstructionJointSealants_KosterJointSealantFS-V 0.8 mm
Type - IFC - IfcExportAs: IfcCoveringType
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_31_76_62: Polysulfide construction joint sealants; Color: n/a; Finish: n/a; Material: Polysulphide; Shape: n/a; Size: n/a; WarrantyDescription: Ten year; CodePerformance: n/a; Constituents: n/a; Description: Stiff/ creamy, two-component polysulphide joint sealant.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Koster Joint Sealant FS-V; Name: PolysulfideConstructionJointSealants_KosterJointSealantFS-V_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_PolysulfideConstructionJointSealants_KosterJointSealantFS-V; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/6123d9c0-ef7b-53b3-8abd-e73e43cc540b/416839c2-9084-4291-9cc4-788f323f95a2; Uniclass2015Code: Pr_30_31_76_62; Uniclass2015Title: Polysulfide construction joint sealants; Uniclass2015Version: Products v1.35; Version: 5
Type - NBS_Data - SealantType: Two part polysulfide; Colour: Black,Grey; ContainsRedListMaterials: No; Recyclability: No; RecycledContent: 0; ApplicationTemperature: 5–40°C; Capacity: ≥80%; ConsumptionPerLayerApplied: 1.6 kg/L; CureTime: 24 H; DeformationCapability: 15%; JointWidthRange: 10–35 mm; MixingTime: 100:13 (A:B); PotLife: 2 H; ShoreAHardness: 35; SpecificGravity: 1.6 kg/L
Classification: Pr_30_31_76_62 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
